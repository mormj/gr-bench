options:
  parameters:
    author: Josh Morman
    generate_options: qt_gui
    id: test_preamble_demod
    output_language: python
    title: Preamble Demodulation
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    const_points: '[1,-1]'
    precision: '8'
    rot_sym: '2'
    sym_map: '[0,1]'
    type: qpsk
  states: {}
- name: data
  id: variable
  parameters:
    value: '[random.getrandbits(8) for i in range(payload_size)]'
  states: {}
- name: eb
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: m
  id: variable
  parameters:
    value: '2'
  states: {}
- name: ntaps
  id: variable
  parameters:
    value: '64'
  states: {}
- name: num_filts
  id: variable
  parameters:
    value: '64'
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: preamble_rrc
  id: variable
  parameters:
    value: utils.preamble_rrc(preamble, constel, m, rrc_taps, sps)
  states: {}
- name: preamble_symbols
  id: variable
  parameters:
    value: utils.preamble_to_symbols(preamble, constel, m)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(0.9, sps, 1, eb, ntaps)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '-87538589'
    type: complex
  states: {}
- name: bench_extract_burst_0
  id: bench_extract_burst
  parameters:
    burst_length: int((8/m)*(len(preamble) + len(data)))
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_copy_0
  id: blocks_copy
  parameters:
    enabled: 'True'
    type: byte
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: len(preamble_symbols)-1
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: m
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_peak_detector2_fb_0
  id: blocks_peak_detector2_fb
  parameters:
    alpha: '0.01'
    look_ahead: '1000'
    threshold_factor_rise: '3'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: preamble + data
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constel
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: constel
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: num_filts
    init_phase: num_filts/2
    loop_bw: 6.28/100.0
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: fft_filter_xxx_0_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: np.conj(np.flipud(preamble_symbols))
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import random
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: int((len(preamble) + len(data))*(8/m))
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: 1024*8
    srate: '1'
    type: float
  states: {}
- name: qtgui_time_sink_x_1_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: 4*(len(preamble)+len(data))
    srate: '1'
    type: float
  states: {}
- name: utils
  id: epy_module
  parameters:
    source_code: |
      # this module will be imported in the into your flowgraph

      import numpy as np
      from scipy import signal

      from gnuradio.filter import firdes

      def preamble_to_symbols(preamble, constel, m):
          # Bytes to unpacked bytes
          # msb first
          
          mask = [0x01,0x03,0x07,0x0F][m-1]
          
          
          unmod_symbols = []
          for ii in range(len(preamble)):
              for jj in range(0,8,m):
                  unmod_symbols.append((preamble[ii] >> ((8-m)-jj)) & mask)
          
          # Constellation modulate
          symbols = [constel.map_to_points_v(p)[0] for p in unmod_symbols]
          return symbols

      def preamble_rrc(preamble, constel, m, rrc_taps, sps):
          symbols = preamble_to_symbols(preamble, constel, m)
          
          symbols_us = np.zeros((len(symbols)*sps), dtype=np.complex64)   
          symbols_us[0::sps] = symbols
          
          # go up by 2
          symbols_rrc_re = signal.convolve([x.real for x in symbols_us], rrc_taps, 'same')
          symbols_rrc_im = signal.convolve([x.imag for x in symbols_us], rrc_taps, 'same')
          
          return symbols_rrc_re + 1j*symbols_rrc_im
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: modulator_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: modulator_out
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '1']
- [bench_extract_burst_0, '0', digital_constellation_decoder_cb_0, '0']
- [bench_extract_burst_0, '0', qtgui_time_sink_x_1_0_0_0, '0']
- [blocks_add_xx_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_char_to_float_1, '0', qtgui_time_sink_x_1_0_0_0_0_0, '1']
- [blocks_char_to_float_1_0, '0', qtgui_time_sink_x_1_0_0_0_0_0_0, '1']
- [blocks_char_to_float_1_0_0, '0', qtgui_time_sink_x_1_0_0_0_0_0_0, '0']
- [blocks_complex_to_mag_0, '0', blocks_peak_detector2_fb_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_1_0_0_0_0_0, '0']
- [blocks_copy_0, '0', blocks_char_to_float_1_0_0, '0']
- [blocks_delay_0, '0', bench_extract_burst_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', blocks_copy_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_peak_detector2_fb_0, '0', bench_extract_burst_0, '1']
- [blocks_peak_detector2_fb_0, '0', blocks_char_to_float_1, '0']
- [blocks_vector_source_x_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_1_0, '0']
- [digital_constellation_encoder_bc_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', blocks_delay_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', fft_filter_xxx_0_0, '0']
- [fft_filter_xxx_0_0, '0', blocks_complex_to_mag_0, '0']
- [interp_fir_filter_xxx_0, '0', virtual_sink_0, '0']
- [virtual_source_0, '0', blocks_add_xx_0, '0']

metadata:
  file_format: 1
