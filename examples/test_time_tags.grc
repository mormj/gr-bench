options:
  parameters:
    generate_options: qt_gui
    id: asdf
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: float
  states: {state: disabled}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: injector
  id: bench_time_tag_injector
  parameters:
    interval: '0.01'
    offset_secs: '0'
  states: {}
- name: latency
  id: bench_latency_meas_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    bins: '100'
    size: '10240'
    type: float
    xmax: '1'
    xmin: '-1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '64000'
    srate: samp_rate
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: print(f'LATENCY_AVG:{self.latency.avg_latency()} microseconds')
    section: main_after_stop
  states: {}
- name: snippet_0_0
  id: snippet
  parameters:
    code: |-
      self.injector.set_max_noutput_items(10)
      self.latency.set_max_noutput_items(10)
    section: main_after_init
  states: {state: disabled}

connections:
- [analog_fastnoise_source_x_0, '0', qtgui_histogram_sink_x_0, '0']
- [analog_sig_source_x_0, '0', injector, '0']
- [blocks_throttle_0, '0', latency, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [injector, '0', blocks_throttle_0, '0']
- [injector, '0', latency, '0']
- [injector, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
